Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-06T15:27:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 06 15:27:09 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{38D36269-F06A-42CE-B6D4-77780619FE36}\ifc * Database version: 5507 * Database creation date: Fri Aug 06 15:27:08 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 06 15:27:08 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 06 15:27:08 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1014F Washbasin faucet with washing machine valve, 1014F(2021):1014F Washbasin faucet with washing machine valve:346344
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 173 mm; FaucetNominalHeight: 163 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 286.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm; Projection: 133 mm
Type - General - Author: BIMstone; BIMObjectName: 1014F(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with washing machine valve and Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 22/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150098635; EN Standard: EN 817; LVI Number: 6110355; Noise Class: I (ISO 3822)
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1014F; Catalog Drawing URL: http://static.oras.com/catdrw/1014F; Class: Single lever;Bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/1014F; FDV Document URL: http://www.oras.com/datasheet/1014F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1014F; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;RUS;EST;LTU;LVA;UKR; Model: 1014F Washbasin faucet with washing machine valve; Name_en: 1014F Washbasin faucet with washing machine valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 1.93 kg; Product Code: 1014F; Product Datasheet: http://www.oras.com/datasheet/1014F/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1014F; Product URL: http://static.oras.com/1014F; Technical DataSheet URL: http://www.oras.com/datasheet/1014F/en; Type Name: 1014F Washbasin faucet with washing machine valve
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: CASCADE®; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00494405 m3/s; Installation and Maintenance: http://static.oras.com/manual/1014F; Installation Type: Deck mounted; Lever Handle: ;Lever with H+C symbol; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Pressure Loss With Flow 01ls: 160000 Pa; Spare Parts: http://static.oras.com/sp/1014F; Spout Swivel Range: 120° (40° / 80°); Spout Type: Swivel spout;;; Temperature Adjustments: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1014F(2021); Features: Single lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1014F; Name: 1014F Washbasin faucet with washing machine valve; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:54x173x163 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0818685 m2; Volume: 0.00237003 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1014F(2021): 1014F Washbasin faucet with washing machine valve; Family and Type: 1014F(2021): 1014F Washbasin faucet with washing machine valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1014F(2021): 1014F Washbasin faucet with washing machine valve; Type Id: 1014F(2021): 1014F Washbasin faucet with washing machine valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
